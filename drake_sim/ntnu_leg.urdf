Commit message: first_working_instance

File: drake_sim/ntnu_leg.urdf (robot description, URDF)
Before this commit: robot ntnu_leg, 6 links, 5 joints
Links:
- removed link world
Joints:
- removed joint jointMH
